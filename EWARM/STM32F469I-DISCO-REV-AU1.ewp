# IAR project STM32F469I-DISCO-REV-AU1.ewp, settings and files
configuration STM32F469I-DISCO-REV-AU1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include; ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32469I-Discovery; ../TouchGFX/generated/videos/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: STM32F469I-DISCO-REV-AU1.hex
  ILINK.IlinkOutputFile: STM32F469I-DISCO-REV-AU1.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: STM32F469I-DISCO-REV-AU1.ipcf
  group Application/EWARM
    ./: startup_stm32f469xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/nt35510/: nt35510.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/BSP/STM32469I-Discovery
    ../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_qspi.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m4f/IAR8.x/: touchgfx_core.a
