# Keil uVision project STM32F469I-DISCO-REV-AU1.uvprojx, settings and files
target STM32F469I-DISCO-REV-AU1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F469I-DISCO-REV-AU1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_BPP=16,ARM_MATH_CM4
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../Drivers/BSP/STM32469I-Discovery;../Middlewares/ST/ARM/DSP/Inc;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/BSP/STM32469I-Discovery
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F469I-DISCO-REV-AU1.sct
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/nt35510/: nt35510.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/BSP/STM32469I-Discovery
    ../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_deng_35_4bpp_0.cpp font_dengb_35_4bpp_0.cpp font_dengb_35_4bpp_10.cpp font_dengb_35_4bpp_11.cpp font_dengb_35_4bpp_12.cpp font_dengb_35_4bpp_13.cpp font_dengb_35_4bpp_14.cpp font_dengb_35_4bpp_15.cpp font_dengb_35_4bpp_17.cpp font_dengb_35_4bpp_18.cpp font_dengb_35_4bpp_19.cpp font_dengb_35_4bpp_9.cpp font_verdana_10_4bpp_0.cpp font_verdana_25_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_deng_35_4bpp.cpp kerning_dengb_35_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_25_4bpp.cpp kerning_verdana_40_4bpp.cpp table_deng_35_4bpp.cpp table_dengb_35_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_25_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_alternate_theme_images_bars_80x480_bottom_base.cpp image_bottom_slide_menu_button.cpp image_button.cpp image_button1.cpp image_compresshorizontal.cpp image_expandhorizontal.cpp image_left_slide_menu_button.cpp image_radio_button_selected.cpp image_radio_button_selected_pressed.cpp image_radio_button_unselected.cpp image_radio_button_unselected_pressed.cpp image_right_slide_menu_button.cpp image_top_slide_menu_button.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_bars_800x480_bottom_base.cpp image_alternate_theme_images_widgets_button_regular_height_60_tiny_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_60_tiny_rounded_pressed.cpp image_alternate_theme_images_widgets_slider_vertical_thick_filler_small.cpp image_alternate_theme_images_widgets_slider_vertical_thick_round_dark.cpp image_alternate_theme_images_widgets_slider_vertical_thick_track_small.cpp image_alternate_theme_images_widgets_swipecontainer_large_off_normal.cpp image_alternate_theme_images_widgets_swipecontainer_large_on_action.cpp image_alternate_theme_images_widgets_togglebutton_large_rounded_text_off_normal.cpp image_alternate_theme_images_widgets_togglebutton_large_rounded_text_on_action.cpp image_dark_theme_images_backgrounds_800x480_asphalt.cpp image_dark_theme_images_widgets_slider_horizontal_thick_filler_large.cpp image_dark_theme_images_widgets_slider_horizontal_thick_round_dark.cpp image_dark_theme_images_widgets_slider_horizontal_thick_track_large.cpp image_icon_theme_images_action_compress_50_50_e8f6fb.svg.cpp image_icon_theme_images_action_expand_50_50_e8f6fb.svg.cpp image_icon_theme_images_navigation_arrow_downward_50_50_e8f6fb.svg.cpp image_icon_theme_images_navigation_arrow_upward_50_50_e8f6fb.svg.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
